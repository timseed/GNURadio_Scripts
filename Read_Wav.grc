options:
  parameters:
    author: Tim Seed
    generate_options: qt_gui
    id: Read_Wav
    output_language: python
    title: Read a Wav File
  states: {}

blocks:
- name: centre_freq
  id: variable_qtgui_range
  parameters:
    label: Centre_Freq
    rangeType: int
    start: '500'
    step: '30'
    stop: '3000'
    value: '2100'
  states: {}
- name: high_pass
  id: variable_qtgui_range
  parameters:
    label: High
    rangeType: int
    start: '800'
    step: '10'
    stop: '3000'
    value: '2200'
  states: {}
- name: low_pass
  id: variable_qtgui_range
  parameters:
    label: Low
    rangeType: int
    start: '500'
    step: '10'
    stop: '3000'
    value: '1900'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: width
  id: variable_qtgui_range
  parameters:
    label: width
    rangeType: int
    start: '10'
    step: '10'
    stop: '1000'
    value: '50'
  states: {}
- name: band_pass_filter_0
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: high_pass
    low_cutoff_freq: low_pass
    samp_rate: samp_rate
    type: fir_filter_fff
    width: width
    win: window.WIN_HAMMING
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: /Volumes/Dev/Python/GNUR/wav/qbf.wav
    repeat: 'True'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    bw: samp_rate
    fc: centre_freq
    fftsize: '256'
    type: float
  states: {}

connections:
- [band_pass_filter_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_throttle2_0, '0', band_pass_filter_0, '0']
- [blocks_wavfile_source_0, '0', blocks_throttle2_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.7.0
